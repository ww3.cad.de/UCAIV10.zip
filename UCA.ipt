# Autodesk Inventor part: UCA
## iProperties
Created: 2006-05
Part Number: UCA
Document SubType Name: Modeling
## Feature names
1. Extrusion1
